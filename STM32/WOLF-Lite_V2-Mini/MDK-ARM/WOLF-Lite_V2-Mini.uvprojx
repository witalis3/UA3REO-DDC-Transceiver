# Keil uVision project WOLF-Lite_V2-Mini.uvprojx, settings and files
target WOLF-Lite_V2-Mini_ST7789 (6190000::V6.19::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: WOLF-Lite2-Mini-ST7789
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=5 oTime=1 OneElfS=1 uGnu=1 v6Lang=5 v6LangP=7 v6Lto=1 wLevel=3
  c define: FRONTPANEL_LITE_V2_MINI,LCD_ST7789,LITE2-MINI,USE_HAL_DRIVER,STM32H743xx,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c misc: -Wno-padded -Wno-implicit-int-float-conversion -Wno-sign-conversion -Wno-implicit-int-conversion -Wno-cast-qual -Wno-cast-align -Wno-implicit-float-conversion -Wno-implicit-fallthrough -Wno-float-equal -Wno-gnu-compound-literal-initializer -Wno-sign-compare -Wno-date-time -Wno-c++98-compat-pedantic -Wno-old-style-cast -Wno-gnu-flexible-array-initializer -Wno-c99-extensions -pipe -Wno-unused-value -Wdouble-promotion
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/STM32H7xx_HAL_Driver/Inc;../../Src;../../Src/USBDevice;../Src;../../Src/JPEG;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\WOLF-Lite_V2-Mini\WOLF_custom.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../../WOLF/Src/: hardware.c
    ../Src/: hardware.h system_stm32h7xx.c fpga.c front_unit.c rf_unit.c lcd.c main.c user_diskio.c fatfs.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../Inc/: main.h
  group Src
    ../../Src/: adpcm-lib.c adpcm-lib.h agc.c agc.h atu.c atu.h audio_filters.c audio_filters.h audio_processor.c audio_processor.h auto_calibration.c auto_calibration.h auto_notch.c auto_notch.h bands.c bands.h bootloader.c bootloader.h callsign.c callsign.h codec.c codec.h codec_wm8731.c codec_nau8822.c color_themes.h cw.c cw.h cw_decoder.c cw_decoder.h decoder.c decoder.h events.c events.h fft.c fft.h filemanager.c filemanager.h fonts.c fonts.h fpga.h front_unit.h functions.c functions.h i2c.c i2c.h images.h lcd.h lcd_driver.c lcd_driver.h lcd_driver_ILI9341.c lcd_driver_ILI9341.h lcd_driver_ILI9481.c lcd_driver_ILI9481.h lcd_driver_NONE.c lcd_driver_NONE.h lcd_driver_RA8875.c lcd_driver_RA8875.h lcd_driver_ST7735S.c lcd_driver_ST7735S.h lcd_driver_ST7789.c lcd_driver_ST7789.h locator.c locator.h noise_blanker.c noise_blanker.h noise_reduction.c noise_reduction.h pre_distortion.c pre_distortion.h print.h profiler.c profiler.h rds_decoder.c rds_decoder.h rf_unit.h rtty_decoder.c rtty_decoder.h screen_layout.h screen_layout_160x128.cpp screen_layout_320x240.cpp screen_layout_480x320.cpp screen_layout_800x480.cpp sd.c sd.h self_test.c self_test.h settings.c settings.h snap.c snap.h spec_analyzer.c spec_analyzer.h swr_analyzer.c swr_analyzer.h system_menu.c system_menu.h touchpad.c touchpad.h touchpad_GT911.c touchpad_GT911.h trx_manager.c trx_manager.h usbd_audio_if.c usbd_audio_if.h usbd_cat_if.c usbd_cat_if.h usbd_debug_if.c usbd_debug_if.h usbd_iq_if.c usbd_iq_if.h usbd_storage_if.c usbd_storage_if.h usbd_ua3reo.c usbd_ua3reo.h vad.c vad.h vocoder.c vocoder.h wifi.c wifi.h wspr.c wspr.h
    ../../Src/FT8/: text.h
  group Src/BiquadDesigner
    ../../Src/BiquadDesigner/: biquad.c biquad.h
  group Src/FT8
    ../../Src/FT8/: constants.c constants.h decode.c decode.h decode_ft8.c decode_ft8.h encode.c encode.h FT8_GUI.c FT8_GUI.h FT8_main.c FT8_main.h gen_ft8.c gen_ft8.h ldpc.c ldpc.h locator_ft8.c locator_ft8.h pack.c pack.h Process_DSP.c Process_DSP.h text.c traffic_manager.c traffic_manager.h unpack.c unpack.h WF_Table.h
  group Src/JPEG
    ../../Src/JPEG/: jpeg_utils.c jpeg_utils.h jpeg_utils_conf_template.h
  group Src/USBDevice
    ../../Src/USBDevice/: usb_device.c usb_device.h usbd_conf.c usbd_conf.h usbd_core.c usbd_core.h usbd_ctlreq.c usbd_ctlreq.h usbd_def.h usbd_desc.c usbd_desc.h usbd_ioreq.c usbd_ioreq.h usbd_msc_bot.c usbd_msc_bot.h usbd_msc_data.c usbd_msc_data.h usbd_msc_scsi.c usbd_msc_scsi.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dma2d.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.h ff.c ff.h ffsystem.c ffunicode.c
target WOLF-Lite_V2-Mini_ILI9341 (6190000::V6.19::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: as above
  output: WOLF-Lite2-Mini-ILI9341
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: as above
  c define: FRONTPANEL_LITE_V2_MINI,LCD_ILI9341,LITE2-MINI,USE_HAL_DRIVER,STM32H743xx,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\WOLF-Lite_V2-Mini\WOLF_custom.sct
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
